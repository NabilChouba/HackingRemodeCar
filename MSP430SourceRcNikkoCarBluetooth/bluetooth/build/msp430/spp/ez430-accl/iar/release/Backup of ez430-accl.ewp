# IAR project Backup of ez430-accl.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  General.OGChipSelectMenu: MSP430BT5190 MSP430BT5190
  General.GStackSize2: 180
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: EZ430_PLATFORM
  ICC430.newCCIncludePaths: ../../../../../../export/include; ../../../../../../export/common_appl; ../../../../../../export/accl_appl; ../../../../../../export/msp430f5438_hal; ../../../../../../private/protocols/common; ../../../../../../private/protocols/hci_transport; ../../../../../../private/protocols/dbase; ../../../../../../private/protocols/el2cap; ../../../../../../private/protocols/hci_1.2; ../../../../../../private/protocols/sdp; ../../../../../../private/protocols/rfcomm; ../../../../../../private/protocols/sm; ../../../../../../private/protocols/write_task; ../../../../../../private/profiles/spp; ../../../../../../private/platforms/spp/accl_arch/msp430; ../../../../../../private/platforms/arch/msp430; ../../../../../../private/platforms/arch/common; ../../../../../../export/FreeRTOS/Source/include; ../../../../../../export/FreeRTOS/Source/portable/IAR/MSP430; ../../../../../../export/FreeRTOS/Demo/msp430_IAR
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: ../../../../../../../bluetooth/export/FreeRTOS/Demo/msp430_IAR; ../../../../../../../bluetooth/export/common_appl
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../../../../../../export/common_appl/: main.c
  group Accelerometer_Application
    ../../../../../../export/common_appl/: appl_bt_rf.c common_cb.c db_gen.c sdk_bluetooth_common_config.h sdk_common.c sdk_pin_config.h sm_storage_pl.c
    ../../../../../../export/accl_appl/: appl_cb.c appl_sdk.c appl_spp.c sdk_bluetooth_config.h sdk_pl.c user_task.c
    ../../../../../../private/platforms/arch/msp430/: msp430_uart.c
  group BT_Stack _Lib
    ../../../lib/iar/: libspp_core.r43 libspp_pl.r43 libTI_init_script_BT_CC2560.r43 libTI_init_script_BT_CC256x.r43
  group EZ430-RF2560_HAL
    ../../../../../../export/msp430f5438_hal/: hal_board.c hal_i2c.c hal_tlv.c hal_usb.c
  group FreeRTOS
    ../../../../../../export/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c
    ../../../../../../export/FreeRTOS/Source/portable/MemMang/: heap_2.c heap_bt.c
    ../../../../../../export/FreeRTOS/Source/portable/IAR/MSP430/: port.c portext.s43
