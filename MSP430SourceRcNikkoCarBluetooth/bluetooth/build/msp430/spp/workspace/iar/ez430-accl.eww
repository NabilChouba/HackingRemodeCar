<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\ez430-accl\iar\release\ez430-accl.ewp</path>
  </project>
  <batchBuild/>
</workspace>


